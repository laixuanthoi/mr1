# Keil uVision project Project.uvprojx, settings and files
target Project (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=4 v6Lang=1 v6LangP=1 wLevel=1
  c define: STM32F4XX, USE_STDPERIPH_DRIVER
  c include: ..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\Libraries\STM32F4xx_StdPeriph_Driver\src;..\Libraries\CMSIS\Include;..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\FreeRTOSV7.3.0\FreeRTOS\Source\include;..\FreeRTOSV7.3.0\FreeRTOS\Source\portable\MemMang;..\FreeRTOSV7.3.0\FreeRTOS\Source\portable\RVDS\ARM_CM4F;..\..\ROBOT_MR1;..\MDK-ARM
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CMSIS
    ../: system_stm32f4xx.c
  group MDK-ARM
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f4xx.s
  group User
    ./: Ban_Tay.h Motor_Hut.h Canh_Tay.h Co_Cau.h Dieu_Khien_Canh_Tay.h Mam_Xoay.h utils.h uart_comunicate.h joystick.h
    ../: stm32f4xx_it.c main.c config.h doc_tay_game.h BasicFunction.h LID_HMI.h FreeRTOSConfig.h DieuKhienCoCau.h ROBOTRUN.h 4OmniControler.h
  group STM32F4xx_StdPeriph_Driver
    ../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_adc.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_spi.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_syscfg.c stm32f4xx_i2c.c
  group FREERTOS
    ../FreeRTOSV7.3.0/FreeRTOS/Source/: croutine.c list.c queue.c timers.c tasks.c
    ../FreeRTOSV7.3.0/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ../FreeRTOSV7.3.0/FreeRTOS/Source/portable/MemMang/: heap_2.c
software components: CMSIS:CORE 5.0.2
